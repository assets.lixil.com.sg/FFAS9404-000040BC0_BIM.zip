Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T10:06:33
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: 90 Degree Angle Safety Grab Bar – Left Hand, FFAS9404-000040BC0:90 Degree Angle Safety Grab Bar – Left Hand:3374
In: Level 1
Type - Classification: C1030200 (Uniformat); Material: Nylon, White
Type - Constraints - Default Elevation: 0 mm
Type - Data - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Pro & Commercial (70); ProductGroup: Grab Bar (03); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Commercial Accessories (17)
Type - Identity Data - Assembly Code: C1030200; Description: 90 Degree Angle Safety Grab Bar – Left Hand; Keynote: N13; Manufacturer: American Standard; Model: 90 Degree Angle Safety Grab Bar – Left Hand; OmniClass Number: 23.40.20.21.47; OmniClass Title: Bath Grab Bars; Type Comments: FFAS9404-000040BC0; Type Name: 90 Degree Angle Safety Grab Bar – Left Hand; URL: https://www.americanstandard-apac.com/
Type - Model Properties - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffas9404-000040bc0/document/object-user-guide; BIMObjectName: AmericanStandard_GrabBar_(FFAS9404-000040BC0); NBSDescription: n/a; NBSNote: n/a; NBSObjectName: American Standard - n/a; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_25_30_36_34; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffas9404-000040bc0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffas9404-000040bc0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffas9404-000040bc0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffas9404-000040bc0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffas9404-000040bc0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: FFAS9404-000040BC0; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: FFAS9404-000040BC0; ModelReference: 90 Degree Angle Safety Grab Bar – Left Hand; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: 90 Degree Angle Safety Grab Bar – Left Hand; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
Pset_BuildingElementProxyCommon - Reference: 90 Degree Angle Safety Grab Bar – Left Hand
Pset_ManufacturerTypeInformation - ModelReference: 90 Degree Angle Safety Grab Bar – Left Hand; Manufacturer: American Standard; ProductionYear: 2021
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0794847 m2; Volume: 0.00131841 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Family: FFAS9404-000040BC0: 90 Degree Angle Safety Grab Bar – Left Hand; Family and Type: FFAS9404-000040BC0: 90 Degree Angle Safety Grab Bar – Left Hand; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: FFAS9404-000040BC0: 90 Degree Angle Safety Grab Bar – Left Hand; Type Id: FFAS9404-000040BC0: 90 Degree Angle Safety Grab Bar – Left Hand; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
AC_Pset_RenovationAndPhasing - Renovation Status: New
